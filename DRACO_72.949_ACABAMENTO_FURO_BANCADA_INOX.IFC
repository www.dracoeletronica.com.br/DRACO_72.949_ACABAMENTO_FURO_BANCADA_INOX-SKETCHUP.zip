Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_72.949_ACABAMENTO_FURO_BANCADA_INOX.IFC
Time: 2023-07-25T11:47:38
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_72.949_ACABAMENTO_FURO_BANCADA_INOX
In: Default Storey
Material: AISI 304
